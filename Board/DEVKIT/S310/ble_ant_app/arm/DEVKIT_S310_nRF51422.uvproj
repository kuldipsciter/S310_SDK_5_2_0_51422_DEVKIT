# Keil uVision project DEVKIT_S310_nRF51422.uvproj, settings and files
target DEVKIT_S310_nRF51422 (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: DEVKIT_S310_nRF51422 +hex
  c flags: Optim=1
  c define: NRF51,DEBUG_NRF_USER,BLE_STACK_SUPPORT_REQD,ANT_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s310;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x20000 size 0x1c000
  memory RVCT9: RAM 0x20002400 size 0x1c00
  group Startup Code
    ../../../../../Source/templates/arm/: arm_startup_nrf51422_s310.s
    ../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ../: main.c battery.c led.c Accelerometer.c temperature_NTC.c co2_sensor.c pwm.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_bas.c ble_dis.c ble_sr.c
  group Libraries
    ../../../../../Source/ble/: ble_error_log.c ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/app_common/: app_timer.c crc16.c pstorage.c app_button.c app_gpiote.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../: aes-cbc.c aes-internal.c aes-internal-dec.c
    ../../../../../Source/twi_master/: twi_master_int.c
    ../../../../../Source/development_kit/: AntEventHandler.c development_kit_config.c
    ../../../../../Source/devkit/: devkit_config.c devkit_application.c devkit_motor.c devkit_command.c devkit_debug.c
    ../../../../../Source/AntAschyncevent/: AntAsyncEvent.c
